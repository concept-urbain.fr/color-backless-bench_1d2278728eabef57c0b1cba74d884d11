Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: COLO-BANQ-001-B.IFC
Time: 2020-05-20T09:46:43
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: COLO-BANQ-004-B_Default (2)
In: Default Storey
Material: 0

# IfcBeam: COLO-BANQ-005_Default
In: Default Storey
Material: AISI 304

# IfcBeam: COLO-MUL-002_Default
In: Default Storey
Material: Moabi

# IfcBeam: H M12 A2_Default (4)
In: Default Storey
Material: 0

# IfcBeam: OCEA-BANQ-MUL-004 (2)
In: Default Storey
Material: AISI 304

# IfcBeam: ROND-M12-A2_Default (7)
In: Default Storey
Material: 0

# IfcBeam: TH M12x40 DIN931 A2_Default (4)
In: Default Storey
Material: 0

# IfcBuildingElementProxy: COLO-BANQ-003-B_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: COLO-BANQ-004-B_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: COLO-BANQ-005_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: AISI 304

# IfcBuildingElementProxy: COLO-MUL-001_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Moabi

# IfcBuildingElementProxy: COLO-MUL-002_Default (5)
In: Default Storey
PredefinedType: ELEMENT; Material: Moabi

# IfcBuildingElementProxy: EVEO-BANQ-MUL-002_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Fonte ductile

# IfcBuildingElementProxy: H M12 A2_Default (10)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: OCEA-BANQ-MUL-004 (19)
In: Default Storey
PredefinedType: ELEMENT; Material: AISI 304

# IfcBuildingElementProxy: ROND-M12-A2_Default (15)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TH M12x40 DIN931 A2_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
